# Repository HAM-Key/Lite-layout

File README.md:

# HAMKey-layout

## BOM
interactive Bom: https://nigh.github.io/HAMKey-Lite-layout/

## PCB Render

## Schematic

## KiCad design HAM-Key.kicad_pcb

Parts:
BATT1: Battery_Cell; BATT2030
BZ1: Buzzer; buzzer_SMD
C1, C2, C3: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C4: 0.47uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C5, C6, C7: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D5: RED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D2, D4: BLUE; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D3: WHITE; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
H1, H2, H3, H4: M3.5; MountingHole_3.5mm_Pad_Via
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
Q1: DTC143Z; SOT-23-3
R1: 470k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2: 1M; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R4, R7: 5.1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R5: NC; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R6: 10R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8: 100k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R9, R10, R11: 470R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R12, R13: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R14: 100R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R15: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW1: SW_Push; SW_Cherry_MX_1.00u_PCB
SW2: SW_SPDT; SS12D06G5
SW3, SW4: SW_SPDT; MSK12
U1: nRF52810_module
U2: DFN-8-1EP_3x3mm_P0.65mm_EP1.55x2.4mm
U3: TSOT-23_HandSoldering
USB1: USB_C_Receptacle_PowerOnly_6P; Type-C-3.2H

Connections:
+3.3V: C2.1, C8.1, J2.4, R7.2, R9.2, R10.2, R11.2, R14.1, SW1.2, SW3.1 (A), SW4.1 (A), U1.7 (P0.28/AIN4), U1.14 (VCC), U3.2 (VOUT)
+5V: C6.1, D4.2 (A), D5.2 (A), R8.1, U2.8 (IN), USB1.A9 (VBUS), USB1.B9 (VBUS)
/BAT+: C5.1, R1.1, SW2.1 (A), U3.3 (VIN)
/BTN: C4.2, SW1.1, U1.12 (P0.06)
/BUZZER: BZ1.2 (+), U1.13 (P0.09)
/CC1: R4.1, R6.2, USB1.A5 (CC1)
/CC2: R3.1, R5.2, USB1.B5 (CC2)
/CHARGING: Q1.3 (C), U1.19 (P0.18)
/LED_BLUE: D2.1 (K), U1.10 (P0.04/AIN2)
/LED_RED: D1.1 (K), U1.9 (P0.01)
/LED_WHITE: D3.1 (K), U1.18 (P0.16)
/SW1: SW3.2 (B), U1.17 (P0.15)
/SW2: SW4.2 (B), U1.16 (P0.14)
/SWDCLK: J2.2, R6.1, U1.22 (SWDCLK)
/SWDIO: J2.3, R5.1, U1.23 (SWDIO)
GND: BATT1.2 (-), C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.1, C8.2, J2.1, Q1.2 (E), R2.2, R3.2, R4.2, R15.2, SW3.3 (C), SW4.3 (C), U1.15 (GND), U2.4 (EN), U2.5 (GND), U2.9, U3.1 (GND), USB1.A12 (GND), USB1.B12 (GND), USB1.S1 (SHIELD)
unnamed: BATT1.1 (+), C7.2, SW2.2 (B), SW2.3 (C), U2.1 (BAT)
unnamed: BZ1.1 (-), R14.2
unnamed: D1.2 (A), R9.1
unnamed: D2.2 (A), R10.1
unnamed: D3.2 (A), R11.1
unnamed: D4.1 (K), R12.1
unnamed: D5.1 (K), R13.1
unnamed: Q1.1 (B), R8.2
unnamed: C3.2, R7.1, U1.21 (P0.21/RST)
unnamed: C1.1, R1.2, R2.1, U1.8 (P0.30/AIN6)
unnamed: R13.2, U2.3 (CHRG)
unnamed: R12.2, U2.2 (FULL)
unnamed: R15.1, U2.6 (ISET)

Notes on the sheet:
蓝牙摩斯码键盘
HelloWorks@GitHub
HAMKey-Lite

Board: 2 copper layers, 61.0 x 60.2 mm, 44 parts (1 on the bottom side), 29 nets.

## Commit log

2023-04-19 Create LICENSE
2023-04-27 [ImgBot] Optimize images
    /HAM-Key.jpg -- 178.36kb -> 167.27kb (6.22%)
2023-04-28 temp commit
2023-04-28 gitignore update
2023-05-06 update gitignore
2023-05-06 gh pages ready
2023-05-06 add bom link
2023-05-25 fix some issue
2023-05-30 [ImgBot] Optimize images
    *Total -- 489.29kb -> 400.57kb (18.13%)
    /plots/schematic.png -- 83.78kb -> 66.96kb (20.07%)
    /plots/HAM-Key-Bottom.png -- 200.20kb -> 162.93kb (18.62%)
    /plots/HAM-Key-Top.png -- 205.30kb -> 170.68kb (16.87%)
2023-05-31 update repo name
